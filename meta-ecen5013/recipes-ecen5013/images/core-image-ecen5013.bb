inherit core-image
CORE_IMAGE_EXTRA_INSTALL += "bash"
IMAGE_FEATURES += "allow-empty-password allow-root-login empty-root-password"
